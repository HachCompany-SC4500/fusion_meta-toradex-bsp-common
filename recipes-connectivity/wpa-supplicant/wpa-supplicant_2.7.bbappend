FILESEXTRAPATHS_prepend := "${THISDIR}/wpa-supplicant:"

SRC_URI += " \
    file://defconfig \
"
